# Keil uVision project 53L9A1_PostprocessSingle.uvprojx, settings and files
target 53L9A1_PostprocessSingle (6190000::V6.19::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: 53L9A1_PostprocessSingle +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32H563xx,USE_NUCLEO_144
  c include: ../Inc;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32H5xx_Nucleo;../../../../../../Drivers/BSP/Components/vl53l9;../../../../../../Utilities/vl53l9-common/vl53l9;../../../../../../Middlewares/ST/media-object/media-c/header-lib/include/public;../../../../../../Middlewares/ST/media-object/transform-c/header-lib/include/public;../../../../../../Middlewares/ST/vl53l9-transform-c/vl53l9-transform-c-lib/include/private;../../../../../../Middlewares/ST/vl53l9-transform-c/vl53l9-transform-c-lib/include/public;../../../../../../Utilities/vl53l9-common
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Application/MDK-ARM
    ./: startup_stm32h563xx.s
  group Application/User
    ../Src/: main.c stm32h5xx_hal_msp.c stm32h5xx_it.c vl53l9_app.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/vl53l9/: vl53l9.c
  group Drivers/BSP/STM32H5xx_Nucleo
    ../../../../../../Drivers/BSP/STM32H5xx_Nucleo/: stm32h5xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_i3c.c stm32h5xx_hal_icache.c stm32h5xx_hal_pcd.c stm32h5xx_hal_pcd_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_usart.c stm32h5xx_hal_usart_ex.c stm32h5xx_ll_dma.c stm32h5xx_ll_exti.c stm32h5xx_ll_gpio.c stm32h5xx_ll_rcc.c stm32h5xx_ll_ucpd.c stm32h5xx_ll_usb.c stm32h5xx_ll_utils.c stm32h5xx_util_i3c.c
  group Middleware/ST/vl53l9-transform-c
    ../../../../../../Middlewares/ST/vl53l9-transform-c/vl53l9-transform-c-lib/src/: vl53l9_calib_utils.c vl53l9_transform.c
  group Middleware/ST/vl53l9-transform-c/algo
    ../../../../../../Middlewares/ST/vl53l9-transform-c/vl53l9-transform-c-lib/src/algo/: confidence.c depth16.c distance_calibration.c distance_check.c dmax.c extract.c flying_pixel.c radial_to_perp.c ratenorm.c reflectance.c sharpener.c tnr.c
  group Utilities
    ../../../../../../Utilities/vl53l9-common/platform/: platform_utils.c
    ../../../../../../Utilities/vl53l9-common/vl53l9/: vl53l9_device.c vl53l9_platform.c vl53l9_utils.c
software components: CMSIS:CORE 5.6.0
