<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\53L9A1_PostprocessSingle.ewp</path>
    </project>
    <batchBuild />
</workspace>
